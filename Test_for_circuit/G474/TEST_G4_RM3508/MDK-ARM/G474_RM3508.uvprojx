# Keil uVision project G474_RM3508.uvprojx, settings and files
target G474_RM3508 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: G474_RM3508 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;./fdrm3508;./fdcan_bsp
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c fdcan.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_fdcan.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group fdcan_bsp
    ./fdcan_bsp/: fdcan_bsp.c fdcan_bsp.h
  group fdrm3508
    ./fdrm3508/: FDRM3508.c FDRM3508.h
software components: CMSIS:CORE 4.3.0
